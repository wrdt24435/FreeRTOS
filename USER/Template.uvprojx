# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\DRIVER;..\HARDWARE;..\APP;..\DRIVER\TOUCH;..\DRIVER\FATFS\exfuns;..\DRIVER\FATFS\src;..\SERVICE;..\GUI;..\FreeRTOS\include;..\FreeRTOS\port
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../APP/: my_task.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_sdio.c
  group HARDWARE
    ../HARDWARE/: clk_timer.c gpio.c rtc.c spi.c sys.c usart.c wwdg.c sdio_sdcard.c cti2c.c heap.c
  group DRIVER
    ../DRIVER/: keyboard_driver.c mon.c rng_driver.c sys_driver.c w25q16.c lcd.c
    ../DRIVER/FATFS/src/option/: cc936.c
    ../DRIVER/FATFS/src/: ff.c diskio.c
    ../DRIVER/FATFS/exfuns/: my_fs.c
  group SERVICE
    ../SERVICE/: service.c LED_package.c flash_package.c rtc_package.c
    ../DRIVER/: flash_service.c rtc_service.c LED_service.c
  group VIEW
    ../GUI/: homeview.c popout.c setupview.c view.c
  group FREE-RTOS
    ../FreeRTOS/port/: heap_4.c port.c
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
